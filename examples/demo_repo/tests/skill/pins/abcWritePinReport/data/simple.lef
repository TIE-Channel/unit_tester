VERSION 5.8 ;
MACRO INVX1
  CLASS CORE ;
  SIZE 0.6 BY 1.2 ;
  PIN A
    DIRECTION INPUT ;
  END A
  PIN B
    DIRECTION OUTPUT ;
  END B
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
END INVX1
END LIBRARY
